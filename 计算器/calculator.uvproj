# Keil uVision project calculator.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: calculator +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: calculator.c cal.c calculate.h 1602.c ISD1760.c
